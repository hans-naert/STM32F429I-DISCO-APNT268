# Keil uVision project apnt268.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apnt268
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY USE_STM32F429I_DISCO_REVE
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c Timer.c Thread.c USBH_MSC.c GUI_SingleThread.c LogVIEWERDLG.c Touch_STMPE811.c stdout_USART.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:Components:ILI9341 1.0.2, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:LED 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:I2C 2.12, CMSIS Driver:SPI 2.18, CMSIS Driver:USART 2.16, CMSIS Driver:USB Host:High-speed 2.25, CMSIS-Compiler:File Interface:MDK-MW File System 1.0.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA2D 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:LTDC 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:SDRAM 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3, File System:CORE 6.16.6, File System:Drive:USB 6.16.6, Graphics Display:STM32F429I-Discovery 1.0.0, USB:CORE 6.17.0, USB:Host:CDC 6.17.0, USB:Host:Custom Class 6.17.0, USB:Host:HID 6.17.0, USB:Host:MSC 6.17.0, USB:Host 6.17.0, Graphics:CORE 6.32.3, Graphics:Input Device:Touchscreen 6.32.3, Graphics:Tools:GUI Builder 6.32.3
